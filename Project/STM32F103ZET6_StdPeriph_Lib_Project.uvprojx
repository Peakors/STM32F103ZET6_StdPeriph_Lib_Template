# Keil uVision project STM32F103ZET6_StdPeriph_Lib_Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103ZET6_StdPeriph_Lib_Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER ARMCC_PRINTF_RETARGET
  c include: .\Start;.\CoreSupport;..\StartLibrary;..\User;..\Library\Inc;..\Library\Src;..\Hardware\Inc;..\Hardware\Src;..\System\Inc;..\System\Src;..\SystemLibrary\Inc;..\SystemLibrary\Src;..\Picture
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CoreSupport
    ./CoreSupport/: core_cm3.c core_cm3.h
  group Start
    ./Start/: startup_stm32f10x_hd.s
  group StartLibrary
    ../StartLibrary/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Library/Inc
    ../Library/Inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Library/Src
    ../Library/Src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Hardware/Inc
    ../Hardware/Inc/: adc.h beep.h delay.h dht11.h gy30.h iic.h ili9486.h key.h lcd_gui.h led.h mqtt.h relay.h sys.h sys_tick.h time4.h timer.h touch.h usart.h usart2.h user_config.h wifi.h
  group Hardware/Src
    ../Hardware/Src/: adc.c beep.c delay.c dht11.c function.c gy30.c iic.c ili9486.c key.c lcd_gui.c led.c mqtt.c relay.c sys_tick.c time4.c timer.c touch.c usart.c usart2.c wifi.c
  group SystemLibrary/Inc
    ../SystemLibrary/Inc/: retarget.h
  group SystemLibrary/Src
    ../SystemLibrary/Src/: retarget.c
  group Picture
    ../Picture/: dzk.h font.h pic.h
